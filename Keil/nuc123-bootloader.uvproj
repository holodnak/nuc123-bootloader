# Keil uVision project nuc123-bootloader.uvproj, settings and files
target nuc123-bootloader (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC123LD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x10FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: nuc123-bootloader
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC123\Include;..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\obj\nuc123-bootloader.sct
  link misc: --map --first='startup_NUC123.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
    ../Library/Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
  group User
    ../: main.c
  group Library
    ../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c spi.c usbd.c gpio.c fmc.c
